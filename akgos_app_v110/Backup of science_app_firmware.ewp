# IAR project Backup of science_app_firmware.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430G2955 MSP430G2955
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $PROJ_DIR$; settings; gsm_driver; water_driver
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: lnk430g2955.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptStrategy: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: flash_tasks.c flash_tasks.h hardware_configs.c hardware_configs.h lnk430g2955.xcl main.c parameters_init.c
  group gsm_driver
    gsm_driver/: gsm_modul_tasks.c gsm_modul_tasks.h queue.c queue.h
  group water_driver
    water_driver/: adc_tasks.c adc_tasks.h rtc_tasks.c rtc_tasks.h
